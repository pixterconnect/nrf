# Keil uVision project loramac_classA_isp4520.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: classA_ISP4520_US +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: ISP4520_US REGION_US915 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74
  c misc: --reduce_paths
  c include: ..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_dtm;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\common;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\hal;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\uart;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\gpiote;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\spi_master;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\delay;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\clock;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\atomic;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\balloc;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log\src;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_memobj;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_section_vars;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\fifo;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\strerror;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\uart;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\util;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\scheduler;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\timer;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\toolchain;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\external\segger_rtt;..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\external\fprintf;..\..\..\..\lora\boards\isp4520;..\..\..\..\lora\boards\mcu\nrf52832;..\..\..\..\lora\system;..\..\..\..\lora\system\crypto;..\..\..\..\lora\radio;..\..\..\..\lora\radio\sx126x;..\..\..\..\lora\mac;..\..\..\..\lora\mac\region;..\..\..\..\util;..\config;.\..\..\
  asm define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../: main.c Commissioning.h
    ../config/: sdk_config.h
  group nRF_Drivers
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c app_error.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/fifo/: app_fifo.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/uart/: app_uart_fifo.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/balloc/: nrf_balloc.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/strerror/: nrf_strerror.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/timer/: app_timer.c
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/scheduler/: app_scheduler.c
  group nRF_Log
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log/src/: nrf_log_frontend.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_str_formatter.c nrf_log_backend_serial.c nrf_log_backend_rtt.c
  group nRF_Segger_RTT
    ../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group LORA\boards\isp4520
    ../../../../lora/boards/isp4520/: board.c gpio-board.c spi-board.c sx126x-board.c
  group LORA\boards\mcu\nrf52832
    ../../../../lora/boards/mcu/nrf52832/: utilities.c
  group LORA\system
    ../../../../lora/system/: delay.c timer.c
    ../../../../lora/system/crypto/: aes.c cmac.c
  group LORA\radio
    ../../../../lora/radio/sx126x/: radio.c sx126x.c
  group LoRa\mac
    ../../../../lora/mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacHelper.c
    ../../../../lora/mac/region/: Region.c RegionCommon.c RegionUS915.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
