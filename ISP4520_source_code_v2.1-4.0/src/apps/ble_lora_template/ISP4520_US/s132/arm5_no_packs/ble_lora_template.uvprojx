# Keil uVision project ble_lora_template.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: ble_lora_template_ISP4520_US +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: ISP4520_US REGION_US915 ARM_MATH_CM4 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_advertising;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_db_discovery;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_dtm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_racp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ans_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_bas;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_bas_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_cscs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_cts_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_dfu;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_dis;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_gls;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hids;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hrs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hts;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ias;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ias_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lbs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lls;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_nus;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_nus_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_rscs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_tps;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\nrf_ble_gatt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\nrf_ble_qwr;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\peer_manager;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\clock;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\comp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\delay;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\gpiote;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\hal;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\i2s;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\lpcomp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\pdm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\power;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\ppi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\qdec;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\rng;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\rtc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\saadc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\spi_master;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\spi_slave;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\swi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\timer;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\twi_master;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\twis_slave;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\uart;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\usbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\wdt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\atomic;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\atomic_fifo;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\balloc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\bsp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\button;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\cli;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\crc16;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\crc32;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\csense;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\csense_drv;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\ecc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log\src;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_memobj;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_section_vars;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\fds;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\fstorage;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\gpiote;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\hardfault;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\hci;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\led_softblink;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\low_power_pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\mem_manager;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\mutex;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\pwr_mgmt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\queue;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\scheduler;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\sensorsim;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\slip;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\strerror;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\timer;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\twi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\twi_mngr;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\uart;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\audio;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\cdc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\generic;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\msc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\config;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\util;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\s132\headers;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\s132\headers\nrf52;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\toolchain;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\external\fprintf;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\external\segger_rtt;..\..\..\..\..\lora\radio;..\..\..\..\..\lora\radio\sx126x;..\..\..\..\..\lora\system;..\..\..\..\..\lora\system\crypto;..\..\..\..\..\lora\mac;..\..\..\..\..\lora\mac\region;..\..\..\..\..\lora\boards;..\..\..\..\..\lora\boards\isp4520;..\..\..\..\..\lora\boards\mcu\nrf52832;..\..\..\;..\config
  asm define: REGION_EU868 ARM_MATH_CM4 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_advertising;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_db_discovery;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_dtm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_racp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ans_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_bas;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_bas_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_cscs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_cts_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_dfu;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_dis;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_gls;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hids;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hrs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_hts;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ias;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_ias_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lbs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_lls;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_nus;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_nus_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_rscs;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\ble_services\ble_tps;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\nrf_ble_gatt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\nrf_ble_qwr;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\ble\peer_manager;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\boards;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\clock;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\comp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\delay;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\gpiote;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\hal;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\i2s;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\lpcomp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\pdm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\power;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\ppi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\qdec;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\rng;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\rtc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\saadc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\spi_master;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\spi_slave;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\swi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\timer;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\twi_master;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\twis_slave;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\uart;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\usbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\drivers_nrf\wdt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\atomic;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\atomic_fifo;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\balloc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\bsp;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\button;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\cli;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\crc16;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\crc32;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\csense;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\csense_drv;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\ecc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_log\src;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_memobj;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\experimental_section_vars;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\fds;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\fstorage;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\gpiote;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\hardfault;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\hci;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\led_softblink;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\low_power_pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\mem_manager;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\mutex;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\pwm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\pwr_mgmt;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\queue;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\scheduler;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\sensorsim;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\slip;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\strerror;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\timer;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\twi;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\twi_mngr;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\uart;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\audio;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\cdc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\generic;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\class\msc;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\usbd\config;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\libraries\util;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\common;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\s132\headers;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\softdevice\s132\headers\nrf52;..\..\..\..\..\nordic_sdk\nRF5_SDK_14.2.0_17b948a\components\toolchain;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x200020e0 size 0xdf20
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_BLE
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/button/: app_button.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/scheduler/: app_scheduler.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/timer/: app_timer.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/crc16/: crc16.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/fds/: fds.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/balloc/: nrf_balloc.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/strerror/: nrf_strerror.c
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../nordic_sdk/nRF5_SDK_14.2.0_17b948a/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group lora_radio
    ../../../../../lora/radio/sx126x/: radio.c sx126x.c
  group lora_system
    ../../../../../lora/system/: delay.c timer.c
    ../../../../../lora/system/crypto/: aes.c cmac.c
    ../../../../../lora/boards/mcu/nrf52832/: utilities.c
  group lora_boards
    ../../../../../lora/boards/isp4520/: board.c gpio-board.c spi-board.c sx126x-board.c
  group lora_mac
    ../../../../../lora/mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacHelper.c
    ../../../../../lora/mac/region/: Region.c RegionCommon.c RegionUS915.c
target flash_s132_nrf52_5.0.0_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x200020e0 size 0xdf20
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.15.0, Device:Startup 8.16.0
